# Keil uVision project template.uvprojx, settings and files
target HC32L196 (6240000::V6.24::ARMCLANG)
  device: HC32L196KCTA HDSC
  pack: HDSC.HC32L19X.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hc32_pro +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\mcu\common;..\..\driver\inc;..\source;..\..\qp\include;..\..\qp\ports\arm-cm\qv\armclang;..\..\qp;..\source\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l19x.s
    ../../mcu/common/: system_hc32l19x.c interrupts_hc32l19x.c
  group source
    ../source/: main.c task_high.c task_low.c task_mid.c
    ../../qp/: bsp.c
  group driver
    ../../driver/src/: ddl.c sysctrl.c flash.c bgr.c adc.c adt.c aes.c bt.c crc.c dmac.c gpio.c i2c.c lpm.c lptim.c lpuart.c reset.c rtc.c spi.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group README
    ../: readme.txt
  group qf
    ../../qp/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group qv
    ../../qp/src/qv/: qv.c
    ../../qp/ports/arm-cm/qv/armclang/: qv_port.c
  group qm
    ../../qp/: period_high.c period_mid.c period_low.c
software components: CMSIS:CORE 6.1.1
